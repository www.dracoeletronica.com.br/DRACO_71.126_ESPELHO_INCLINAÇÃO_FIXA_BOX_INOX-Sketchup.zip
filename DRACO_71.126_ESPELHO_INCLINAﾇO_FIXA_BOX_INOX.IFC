Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_71.126_ESPELHO_INCLINAÇÃO_FIXA_BOX_INOX.IFC
Time: 2022-06-10T15:09:39
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: DRACO_71.126_ESPELHO_INCLINAÇÃO_FIXA_BOX_INOX
In: Default Storey
Material: AISI 304
